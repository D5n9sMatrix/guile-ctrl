options:
  parameters:
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_adaptive_algorithm_1
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_adaptive_algorithm_2
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_adaptive_algorithm_3
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_adaptive_algorithm_4
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_adaptive_algorithm_5
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_adaptive_algorithm_6
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_adaptive_algorithm_7
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_entry_1
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_entry_2
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_entry_3
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: variable_tag_object_0
  id: variable_tag_object
  parameters:
    key: pmt.intern("key")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("value")
  states: {}
- name: variable_tag_object_1
  id: variable_tag_object
  parameters:
    key: pmt.intern("key")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("value")
  states: {}
- name: variable_tag_object_2
  id: variable_tag_object
  parameters:
    key: pmt.intern("key")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("value")
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '1'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    affinity: '8'
    alias: edge url
    bits_per_byte: '1'
    comment: |-
      edge url additive scrabler url to full metho easy changes logical move files
      and packages introduction lisp
    count: '0'
    len: '14'
    mask: '0x8A'
    maxoutbuf: '6200'
    minoutbuf: '512'
    reset_tag_key: repl
    seed: '0x7F'
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    affinity: '8'
    alias: rede-aleluia
    comment: headers matrix server connect home
    framesize2: FECFRAME_NORMAL
    maxoutbuf: '6200'
    minoutbuf: '512'
    rate3: C1_4
    rolloff: RO_0_05
    standard: STANDARD_DVBS2
  states: {}
- name: filter_delay_fc_0
  id: filter_delay_fc
  parameters: {}
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    affinity: hope-live
    alias: rede-aleluia
    bandwidth: '278022'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Design'''
    fpass: '200'
    frequency: '278022'
    fstop: '200'
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'True'
    type: sc16
    uri: https://www.gnuduplex.org
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'True'
    type: complex
  states: {}
- name: network_tcp_source_1
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'True'
    type: complex
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '1234'
    src_zeros: 'False'
    type: complex
  states: {}
- name: parameter_0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '640'
    fps: '0'
    height: '480'
    type: byte
    width: '640'
  states: {}
- name: vocoder_alaw_decode_bs_0
  id: vocoder_alaw_decode_bs
  parameters: {}
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: '8'
    affinity: '8'
    alias: rede-aleluia
    comment: times sleep
    hwm: '39'
    maxoutbuf: '6200'
    minoutbuf: '512'
    pass_tags: 'True'
    timeout: '100'
    type: float
    vlen: '8'
  states: {}
- name: zeromq_req_source_2
  id: zeromq_req_source
  parameters:
    address: '8'
    affinity: '8'
    alias: rede-aleluia
    comment: string good day
    hwm: '39'
    maxoutbuf: '6200'
    minoutbuf: '512'
    pass_tags: 'True'
    timeout: '100'
    type: float
    vlen: '8'
  states: {}

connections:
- [audio_source_0, '0', hilbert_fc_0, '0']
- [blocks_interleave_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', video_sdl_sink_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', digital_additive_scrambler_bb_0, '0']
- [filter_delay_fc_0, '0', iio_fmcomms2_sink_0, '1']
- [hilbert_fc_0, '0', iio_fmcomms2_sink_0, '0']
- [network_tcp_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [network_tcp_source_1, '0', blocks_interleave_0, '0']
- [network_udp_source_0, '0', blocks_interleave_0, '1']
- [vocoder_alaw_decode_bs_0, '0', vocoder_alaw_decode_bs_0, '0']
- [zeromq_req_source_0, '0', filter_delay_fc_0, '0']
- [zeromq_req_source_2, '0', filter_delay_fc_0, '1']

metadata:
  file_format: 1
